* Autogenerated spice file from design_project.m

* ee114 device models
.include /usr/class/ee214/hspice/ee214_hspice.sp

r1  n_vdd n_x   732.5
r2  n_vdd n_w   366.3
r21 n_vdd n_w1   366.3
rf  n_ox  n_i   730.0

cl        n_o   0   20.0f
cd        n_i   0   200.0f
*cf        n_ox  n_i 56.1f
c_magic_0 n_z   0   1.0
c_magic_2 n_z1   0   1.0
c_magic_1 n_b   0   1.0

m1    n_x   n_g   n_i   0     nmos214       w=20.9u l=0.18u
m2    n_y   n_x   n_z   0     nmos214       w=58.3u l=0.18u
m3    n_w   n_c   n_y   0     nmos214       w=51.2u l=0.18u
m4    n_vdd n_w1  n_o   0     nmos214       w=117.8u l=0.18u

m21   n_y1  n_w   n_z1   0     nmos214       w=58.3u l=0.18u
m31   n_w1  n_c   n_y1   0     nmos214       w=51.2u l=0.18u

mb1   n_i   n_b   0     0     nmos214       w=46.8u l=0.36u
mb2   n_z   n_b   0     0     nmos214       w=108.4u l=0.36u
mb21  n_z1  n_b   0     0     nmos214       w=108.4u l=0.36u
mb3   n_o   n_b   0     0     nmos214       w=276.9u l=0.36u

vdd   n_vdd   0     1.8
vg    n_g     0     1.149
vc    n_c     0     1.725
vx    n_o     n_ox  0
is    n_i     0   DC=0  AC=1
ib    n_vdd   n_b 222.222u
mb4   n_b     n_b   0     0     nmos214       w=13.8u l=0.36u

.op
.ac dec 1000 1e3 1000e9
.lstb mode=single vsource=vx
.probe ac lstb(db) lstb(p)
.pz v(n_o) is
.noise v(n_o) is
.option post brief accurate
.end
