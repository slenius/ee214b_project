* Autogenerated spice file from design_project.m

* ee114 device models
.include /usr/class/ee214/hspice/ee214_hspice.sp

r1  n_vdd n_x   400.0
r2  n_vdd n_w   8298.1
rgc n_vdd n_v   400.0
rf  n_ox  n_x   2.2

cl        n_o   0   20.0f
cd        n_i   0   200.0f
cf        n_ox  n_x 0.0f
c_magic_0 n_z   0   1.0
c_magic_1 n_b   0   1.0

m1    n_x   n_v   n_i   0     nmos214       w=-467.4u l=0.18u
m2    n_y   n_x   n_z   0     nmos214       w=52.0u l=0.18u
m3    n_w   n_c   n_y   0     nmos214       w=87.4u l=0.18u
m4    n_vdd n_w   n_o   0     nmos214       w=193.2u l=0.18u
m5    n_v   n_i   0     0     nmos214       w=70.2u l=0.18u

mb1   n_i   n_b   0     0     nmos214       w=-1136.6u l=0.36u
mb2   n_z   n_b   0     0     nmos214       w=92.2u l=0.36u
mb3   n_o   n_b   0     0     nmos214       w=943.1u l=0.36u

vdd   n_vdd   0     1.8
vg    n_g     0     1.467
vc    n_c     0     6.322
vx    n_o     n_ox  0
is    n_i     0   DC=0  AC=1
ib    n_vdd   n_b 222.222u
mb4   n_b     n_b   0     0     nmos214       w=47.2u l=0.36u
.op
.ac dec 1000 1e3 1000e9
.lstb mode=single vsource=vx
.probe ac lstb(db) lstb(p)
.pz v(n_o) is
.noise v(n_o) is
.option post brief accurate
.end
